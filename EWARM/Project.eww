<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\nucleo_l476RG_sx1280.ewp</path>
  </project>
  <batchBuild />
</workspace>
